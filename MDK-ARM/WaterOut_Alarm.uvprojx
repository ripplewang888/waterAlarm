# Keil uVision project WaterOut_Alarm.uvprojx, settings and files
target WaterOut_Alarm (ARM-ADS)
  device: STM32L031K6Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: WaterOut_Alarm
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L031xx
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32L0xx_HAL_Driver/Inc;  ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;  ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal.c stm32l0xx_hal_uart.c stm32l0xx_hal_flash.c stm32l0xx_hal_tim.c stm32l0xx_hal_i2c.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Application/MDK-ARM
    ./: startup_stm32l031xx.s
  group Application/User
    ../Src/: usart.c stm32l0xx_hal_msp.c main.c gpio.c stm32l0xx_it.c ringBuffer.c nb_bc95.c
software components: CMSIS:CORE 4.1.0
